options:
  parameters:
    author: John Malsbury - Ettus Research
    category: Custom
    description: Working with the USRP!
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: Lesson 3 - FM Rx
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: 96e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    min_len: '700'
    start: 80e6
    step: 10e3
    stop: 148e6
    value: freqd
  states: {}
- name: freqd
  id: variable
  parameters:
    value: 145.29e6
  states: {}
- name: lpf_decim
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: sel
  id: variable_qtgui_chooser
  parameters:
    label0: standard
    label1: passthru
    label2: power
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: simplesql
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '5'
    stop: '0'
    value: '-25'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: squelch
    rangeType: int
    start: '-10'
    step: '1'
    stop: '70'
    value: '20'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '1'
    value: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: simplesql
  states: {}
- name: analog_standard_squelch_0
  id: analog_standard_squelch
  parameters:
    audio_rate: '96000'
    threshold: squelch
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/lpf_decim
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '96000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: sel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: lpf_decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: input
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: post
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/lpf_decim/1000)
    interp: '96'
    type: fff
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    antenna: Antenna A
    center_freq: freq
    gain: '-10'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', analog_wfm_rcv_0, '0']
- [analog_standard_squelch_0, '0', blocks_selector_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_1, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0, '0', analog_standard_squelch_0, '0']
- [rational_resampler_xxx_0, '0', blocks_selector_0, '1']
- [soapy_sdrplay_source_0, '0', low_pass_filter_0, '0']
- [soapy_sdrplay_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1

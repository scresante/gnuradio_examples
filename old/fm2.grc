options:
  parameters:
    author: shawn
    generate_options: qt_gui
    id: fm2
    output_language: python
    title: fm2
  states: {}

blocks:
- name: cutoff
  id: variable_qtgui_dial_control
  parameters:
    label: cutoff
    maximum: '150000'
    minimum: '50000'
    showvalue: 'True'
    type: int
    value: '100000'
  states: {state: disabled}
- name: cutoff
  id: variable_qtgui_range
  parameters:
    label: cutoff
    start: '1000'
    step: '25000'
    stop: '200000'
    value: '100000'
  states: {}
- name: decimation1
  id: variable_qtgui_range
  parameters:
    label: decimation resampler
    rangeType: int
    start: '1'
    step: '1'
    stop: '12'
    value: '12'
  states: {}
- name: decimation2
  id: variable_qtgui_range
  parameters:
    label: decimation rx
    rangeType: int
    start: '1'
    step: '1'
    stop: '12'
    value: '4'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    min_len: '600'
    start: '87000000'
    step: '100000'
    stop: '108000000'
    value: freq_def
  states: {}
- name: freq_def
  id: variable
  parameters:
    value: '91100000'
  states: {}
- name: quad
  id: variable_qtgui_range
  parameters:
    label: quadrature rate
    min_len: '500'
    start: '10000'
    step: '50000'
    stop: '800000'
    value: '192000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: decimation2
    quad_rate: quad
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.5'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000000'
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation1
    interp: '1'
    type: ccc
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    antenna: Antenna A
    center_freq: freq
    gain: '-20'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [soapy_sdrplay_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    author: shawn
    generate_options: qt_gui
    id: nfm
    output_language: python
    title: narrow fm
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    start: '80000000'
    step: '5000'
    stop: '150000000'
    value: freq_def
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1200000'
  states: {state: disabled}
- name: freq_def
  id: variable
  parameters:
    value: '91100000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    start: '0'
    step: '1'
    stop: 1e8
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '.7'
    type: complex
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '8'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: 48e3
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '8'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: '384000'
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1500'
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '12'
    type: ccf
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    antenna: Antenna A
    center_freq: freq
    gain: '-20'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc3_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_agc3_xx_0, '0', analog_fm_demod_cf_0, '0']
- [analog_agc_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_agc_xx_0, '0', analog_fm_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc3_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc_xx_0, '0']
- [soapy_sdrplay_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1

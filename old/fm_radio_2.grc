options:
  parameters:
    author: Shawn Cresante
    category: Custom
    copyright: Public Domain
    description: Works with SDRPlay
    generate_options: qt_gui
    id: fm_am_receiver
    output_language: python
    title: FM/AM Receiver
  states: {}

blocks:
- name: amfm
  id: variable_qtgui_chooser
  parameters:
    label: AM/FM
    label0: AM
    label1: FM
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: fft_refresh
  id: variable
  parameters:
    value: 1/15
  states: {}
- name: filter_taps
  id: variable
  parameters:
    value: firdes.low_pass(1,samp_rate,100e3,1e3)
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: RF Frequency
    start: 88.3e6
    step: 0.01e6
    stop: 148e6
    value: 127.85e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: RF Frequency
    start: 600e3
    step: 10e3
    stop: 2000e3
    value: 1260e3
  states: {state: disabled}
- name: psth
  id: variable_qtgui_range
  parameters:
    label: Power Threshold (dB)
    start: '-70'
    step: '1'
    stop: '10'
    value: '-30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: sdr_samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: sel
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: Squelch
    outputmsgname: value2
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    label: volume
    start: '0'
    step: '0.05'
    stop: '1'
    value: '1'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '6000'
    audio_stop: '8000'
    chan_rate: 48e3
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: psth
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: sel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: amfm
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: filter_taps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: RF Input
    type: complex
    update_time: fft_refresh
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_3_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: Resampled
    type: complex
    update_time: fft_refresh
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_3_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: Filtered
    type: complex
    update_time: fft_refresh
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_3_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Demodulated FM
    type: float
    update_time: fft_refresh
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_3_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Demodulated AM
    type: float
    update_time: fft_refresh
    wintype: window.WIN_FLATTOP
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '50'
    type: fff
  states: {}
- name: soapy_sdrplay_source_0_0
  id: soapy_sdrplay_source
  parameters:
    antenna: Antenna A
    center_freq: freq
    gain: '-10'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_am_demod_cf_0, '0', blocks_selector_0_0, '0']
- [analog_am_demod_cf_0, '0', qtgui_freq_sink_x_3_0_0_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_selector_0, '1']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_selector_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_3_0, '0']
- [blocks_selector_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_am_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_3_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_selector_0_0, '1']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_3_0_0_0, '0']
- [soapy_sdrplay_source_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [soapy_sdrplay_source_0_0, '0', blocks_selector_0, '0']
- [soapy_sdrplay_source_0_0, '0', qtgui_freq_sink_x_3, '0']

metadata:
  file_format: 1

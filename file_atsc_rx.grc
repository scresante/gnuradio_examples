options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: file_atsc_rx
    output_language: python
    run_options: run
    title: Receive ATSC from UHD
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: atsc_sym_rate
  id: variable
  parameters:
    value: 4.5e6/286*684
  states: {}
- name: duration
  id: variable
  parameters:
    value: '30'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 479e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '18'
  states: {}
- name: oversampled_rate
  id: variable
  parameters:
    value: atsc_sym_rate*sps
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 7e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1.1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: mpeg.ts
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/shawn/radio/gnuradio/gqrx_20220221_014721_479000000_7000000_fc.raw
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: dtv_atsc_rx_0
  id: dtv_atsc_rx
  parameters:
    rate: sample_rate
    sps: '1.5'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: byte
  states: {state: disabled}
- name: soapy_sdrplay_source_0_0
  id: soapy_sdrplay_source
  parameters:
    antenna: Antenna A
    bandwidth: 8e6
    center_freq: freq
    gain: '-20'
    samp_rate: sample_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', dtv_atsc_rx_0, '0']
- [dtv_atsc_rx_0, '0', blocks_file_sink_0, '0']
- [dtv_atsc_rx_0, '0', network_udp_sink_0, '0']
- [soapy_sdrplay_source_0_0, '0', dtv_atsc_rx_0, '0']

metadata:
  file_format: 1
